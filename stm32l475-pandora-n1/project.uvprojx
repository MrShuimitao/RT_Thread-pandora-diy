# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32L475xx
  c include: .;..\..\..\include;.;applications;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;packages\aht10-latest;packages\at_device-v2.0.1\inc;packages\at_device-v2.0.1\class\esp8266;packages\cJSON-v1.0.2;packages\onenet-latest\inc;packages\pahomqtt-v1.1.0\MQTTPacket\src;packages\pahomqtt-v1.1.0\MQTTClient-RT;packages\webclient-v2.1.2\inc;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\sensors;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\net\at\include;..\..\..\components\net\at\at_socket;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\libraries\STM32L4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/ports/: sensor_port.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_soft_i2c.c drv_common.c
  group aht10
    packages/aht10-latest/: aht10.c sensor_asair_aht10.c
  group at_device
    packages/at_device-v2.0.1/src/: at_device.c
    packages/at_device-v2.0.1/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-v2.0.1/samples/: at_sample_esp8266.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group onenet
    packages/onenet-latest/src/: onenet_http.c onenet_mqtt.c
  group paho-mqtt
    packages/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-v1.1.0/MQTTClient-RT/: paho_mqtt_pipe.c
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Sensors
    ../../../components/drivers/sensors/: sensor.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_client.c
    ../../../components/net/at/at_socket/: at_socket.c
  group netdev
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal_socket/impl/: af_inet_at.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32_HAL
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c
